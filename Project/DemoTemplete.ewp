# IAR project DemoTemplete.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Realplum IndieSemi Realplum
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __CHECK_DEVICE_DEFINES
  ICCARM.CCIncludePath2: ..\Src\drivers\hal\inc; ..\Src\drivers\hdf; ..\Src\usr\common; ..\Src\drivers\hdf\sfrs; ..\Src\drivers\core\inc; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include; ..\Src\drivers\hwcfg\inc; ..\Src\usr\library; ..\Src\Function_Blocks\ColorMixingTask; ..\Src\usr\leds
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: DemoTemplete.out
  ILINK.IlinkIcfFile: E:\iNMECH\00_My_Test\06_indie\DemoTemplete\Src\Realplum_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Src/usr/: main.c
  group applications/config
    ../Src/usr/common/: appConfig.h
  group applications/include
    ../Src/Function_Blocks/ColorMixingTask/: colorFormula.h
  group applications/src
    ../Src/usr/common/: applicationTask.c colorCompensationTask.c linMasterTask.c linSlaveTask.c measureTask.c safetyMonitorTask.c
  group drivers/core
    ../Src/drivers/core/src/: cstartup_M.c low_level_init.c
  group drivers/hal
    ../Src/drivers/hal/src/: adc_device.c clock_device.c flash_device.c gpio_device.c hwProtection.c lin_device.c pmu_device.c pwm_device.c systick_device.c timer_device.c wdt_device.c
  group drivers/hdf
    ../Src/drivers/hdf/sfrs/: adc_sfr.h crga_sfr.h evthold_sfr.h gpio_sfr.h ioctrla_sfr.h linm_sfr.h lins_sfr.h pmua_sfr.h pwm_sfr.h realplum_sfr.h sysctrla_sfr.h timer0_sfr.h timer1_sfr.h timer2_sfr.h wdt1_sfr.h wdta_sfr.h wica_sfr.h
  group drivers/hwcfg
    ../Src/drivers/hwcfg/src/: hwcfg.c
  group library
    ../Src/usr/library/: ColorMixingTask.a SoftTimerTask.a
    ../Src/usr/leds/: LedParamTables.c
  group tasks
    ../Src/usr/common/: systemInit.c taskManager.c
